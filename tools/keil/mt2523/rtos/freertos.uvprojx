# Keil uVision project freertos.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT2523x MediaTek
  pack: MediaTek.MTx.4.6.2
  cpu: IROM(0x08000000,0x00400000) IRAM(0x00000000,0x00400000) IRAM2(0x04008000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_thread_creation
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: MTK_DEBUG_LEVEL_INFO,PRODUCT_VERSION=2523,MTK_HAL_NO_LOG_ENABLE
  c misc: --c99
  c include: .\inc;..\..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt2523\inc;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x0 size 0x400000
  memory RVCT10: RAM 0x4008000 size 0x20000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __Vectors
  group app
    ./src/: main.c
  group cmsis
    ./src/: system_mt2523.c startup_mt2523.s
software components: Device:HAL:ACCDET 4.6.0, Device:HAL:ADC 4.6.0, Device:HAL:AUDIO 4.6.0, Device:HAL:CACHE 4.6.0, Device:HAL:CHARGING 4.6.0, Device:HAL:CLOCK 4.6.0, Device:HAL:COMMON 4.6.0, Device:HAL:DAC 4.6.0, Device:HAL:EINT 4.6.0, Device:HAL:FLASH 4.6.0, Device:HAL:GDMA 4.6.0, Device:HAL:GPIO 4.6.0, Device:HAL:GPT 4.6.0, Device:HAL:I2C MASTER 4.6.0, Device:HAL:I2S 4.6.0, Device:HAL:ISINK 4.6.0, Device:HAL:KEYPAD 4.6.0, Device:HAL:MPU 4.6.0, Device:HAL:NVIC 4.6.0, Device:HAL:PMU 4.6.0, Device:HAL:PWM 4.6.0, Device:HAL:RTC 4.6.0, Device:HAL:SD 4.6.0, Device:HAL:SDIO 4.6.0, Device:HAL:SLEEP 4.6.0, Device:HAL:SPI MASTER 4.6.0, Device:HAL:SPI SLAVE 4.6.0, Device:HAL:TRNG 4.6.0, Device:HAL:UART 4.6.0, Device:HAL:WDT 4.6.0, Device:RTOS:Free RTOS 4.6.0
