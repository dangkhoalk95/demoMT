# Keil uVision project libwifibsp_CM4_KEIL.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT2523x MediaTek
  pack: MediaTek.MTx.4.2.0
  cpu: IROM(0x08000000,0x00400000) IRAM(0x00000000,0x00400000) IRAM2(0x04008000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: libwifibsp_CM4_KEIL (library)
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: MTK_DEBUG_LEVEL_INFO PRODUCT_VERSION=2523 MTK_NVDM_ENABLE MTK_WIFI_ENABLE MTK_WIFI_CHIP_USE=MT5931 MTK_FOTA_ENABLE MTK_WIFI_CHIP_USE_MT5931 MT5931 __WIFI_HIF_SDIO__=1 __WIFI_SUPPORT__ WCN_MAUI __MTK_TARGET__
  c misc: --C99 --diag_suppress=1295
  c include: ..\..\..\..\..\..\CMSIS\Device\MTK\mt2523\Include;..\..\..\..\..\..\CMSIS\Include;..\..\..\..\..\..\..\kernel\service\inc;..\..\..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\chip\mt2523\inc;..\..\..\..\..\..\chip\inc;..\..\..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\..\..\middleware\MTK\atci\inc;..\..\..\..\..\..\..\middleware\third_party\lwip\src\include;..\..\..\..\..\..\..\middleware\third_party\lwip\src\include\lwip;..\..\..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\inc;..\..\..\..\..\component\wifi\mt5931\inc;..\..\..\..\..\..\..\project\mt2523_hdk\apps\modem_wifi5931_ref_design\inc
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x0 size 0x400000
  memory RVCT10: RAM 0x4008000 size 0x20000
  group src
    ../: kal_public_api.c mtk_hw_adapter.c mtk_wifi_adapter.c stack_ltlcom.c wifi_api.c wifi_atci.c wifi_common_config.c wndrv_configure.c
