# Keil uVision project libwndrv_CM4_KEIL.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT2523x MediaTek
  pack: MediaTek.MTx.4.2.0
  cpu: IROM(0x08000000,0x00400000) IRAM(0x00000000,0x00400000) IRAM2(0x04008000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: libwndrv_CM4_KEIL (library)
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: MTK_DEBUG_LEVEL_INFO PRODUCT_VERSION=2523 MTK_NVDM_ENABLE MTK_WIFI_ENABLE MTK_WIFI_CHIP_USE=MT5931 MTK_FOTA_ENABLE MTK_WIFI_CHIP_USE_MT5931 MT5931 __WIFI_HIF_SDIO__=1 __WIFI_SUPPORT__ WCN_MAUI __MTK_TARGET__
  c misc: --C99 --diag_suppress=1295
  c include: ..\inc;..\..\..\..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include;..\..\..\..\..\..\..\driver\chip\inc;..\..\..\..\..\..\..\driver\chip\mt2523\inc;..\..\..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\..\..\kernel\service\inc;..\..\..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\..\driver\board\mt25x3_hdk\ept\inc;..\..\..\..\..\..\..\driver\board\mt25x3_hdk\keypad\inc;..\..\..\..\..\..\..\project\mt2523_hdk\apps\modem_wifi5931_ref_design\inc;..\..\inc\mgmt;..\..\inc\nic;..\..\inc\os;..\..\inc\release_mt5931;..\..\inc;..\..\..\..\..\mt25x3_hdk\wifi\mt5931\inc
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x0 size 0x400000
  memory RVCT10: RAM 0x4008000 size 0x20000
  group src
    ../release_mt5931/: wndrv_api.c wndrv_kal.c
    ../common/: smart_conn_decoder.c wlan_bow.c wlan_lib.c wlan_oid.c wndrv_crypt_aes.c
    ../mgmt/: auth.c bss.c cnm.c cnm_mem.c cnm_timer.c hem_mbox.c mib.c privacy.c rate.c rlm.c rlm_domain.c rlm_obss.c roaming_fsm.c rsn.c saa_fsm.c scan.c scan_fsm.c sec_fsm.c sms4.c aaa_fsm.c ais_fsm.c assoc.c swcr.c wapi.c
    ../nic/: cmd_buf.c nic.c nic_cmd_event.c nic_pwr_mgt.c nic_rx.c nic_tx.c que_mgt.c
    ../os/: gl_hpi.c gl_kal.c gl_rftest.c loopback.c mt5931_firmware.c wlan_kal.c wlan_wt.c wndrv_create.c wndrv_hostap_func.c wndrv_inject_msg.c wndrv_main.c wndrv_misc.c wndrv_rftest_func.c wndrv_supc_func.c
