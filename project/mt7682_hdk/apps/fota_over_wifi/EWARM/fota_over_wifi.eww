<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$\fota_over_wifi.ewp</path>
  </project>
  <batchBuild/>
</workspace>


