# IAR project sleep_manager_power_mode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MTK_DEBUG_LEVEL_INFO; MTK_NO_PSRAM_ENABLE; PCFG_OS=2; _REENT_SMALL; PRODUCT_VERSION=7682; MT5932_SINGLE_CONTEXT; MTK_ROM_VER=e1; MTK_WIFI_ROM_ENABLE; MTK_CM4_WIFI_TASK_ENABLE; MTK_CM4_N9_SINGLE_IMG; MTK_HIF_HEADER_2DW; MTK_DEBUG_LEVEL_DEBUG; MTK_DEBUG_LEVEL_INFO; MTK_DEBUG_LEVEL_WARNING; MTK_DEBUG_LEVEL_ERROR; MTK_LWIP_ENABLE; MTK_MT7686_ENABLE; USE_HAL_DRIVER; USE_HAL_DRIVER; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7686\Include; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\chip\mt7686\inc; ..\..\..\..\..\middleware\MTK\connsys\inc; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt7686\src\common\include; ..\..\..\..\..\middleware\MTK\tftp\inc; ..\..\..\..\..\middleware\third_party\cjson\inc; ..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\middleware\third_party\lwip\src\include\lwip; ..\..\..\..\..\middleware\MTK\dhcpd\inc; ..\..\..\..\..\middleware\third_party\mbedtls\include; ..\..\..\..\..\middleware\third_party\mbedtls\configs; ..\..\..\..\..\middleware\MTK\minicli\inc; ..\..\..\..\..\middleware\third_party\mqtt\MQTTClient-C\src\mediatek; ..\..\..\..\..\middleware\third_party\mqtt\MQTTClient-C\src; ..\..\..\..\..\middleware\third_party\mqtt\MQTTPacket\src; ..\..\..\..\..\middleware\third_party\nghttp2\lib\includes; ..\..\..\..\..\middleware\third_party\nghttp2\lib\includes\nghttp2; ..\..\..\..\..\middleware\MTK\smtcn\inc; ..\..\..\..\..\middleware\third_party\sntp\inc; ..\..\..\..\..\middleware\third_party\xml\inc; ..\..\..\..\..\middleware\MTK\iperf\inc; ..\..\..\..\..\middleware\third_party\ping\inc; ..\..\..\..\..\project\common\bsp_ex\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\middleware\third_party\curve25519\inc; ..\..\..\..\..\middleware\third_party\ed25519\inc; ..\..\..\..\..\middleware\third_party\chacha20poly1305\inc; ..\..\..\..\..\middleware\third_party\srp\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\MTK\wifi_service\combo\inc; ..\..\..\..\..\driver\board\mt76x7_hdk\util\inc; ..\inc; inc; src\common\include; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7686\Include; ..\..\..\..\..\driver\CMSIS\Include; ..\..\inc; inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7686\Include; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\board\mt7686_hdk\inc; ..\..\..\..\..\driver\chip\mt7686\src\common\include; ..\..\..\..\..\driver\chip\mt7686\inc; ..\..\..\..\..\kernel\service\inc; include; ..\..\..\..\..\driver\board\mt7686_hdk\ept\inc; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7686\Include; ..\..\..\..\..\project\mt7682_hdk\hal_examples\sleep_manager_power_mode\inc; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7686\Include; ..\..\..\..\..\driver\chip\mt7686\inc; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\driver\board\mt7686_hdk\ept\inc; ..\..\..\..\..\middleware\MTK\verno\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sleep_manager_power_mode.bin
  ILINK.IlinkOutputFile: sleep_manager_power_mode.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group lib
    ../../../../../prebuilt/driver/chip/mt7686/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
  group driver/board
    ../../../../../driver/board/mt7686_hdk/ept/src/: bsp_gpio_ept_config.c
  group driver/chip
    ../../../../../driver/chip/mt7686/src/: hal_i2s.c hal_i2s_internal.c hal_uart.c hal_uart_internal.c hal_log.c hal_nvic.c hal_nvic_internal.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_flash_custom_sfi.c hal_flash_combo_init.c hal_flash_cfi.c hal_flash_custom.c hal_flash_combo_nor.c hal_flash_disk.c hal_flash_mtd.c hal_gdma.c hal_gdma_internal.c hal_pdma_internal.c hal_emi.c hal_gpt.c hal_gpt_internal.c hal_cache.c hal_cache_internal.c hal_mpu.c hal_mpu_internal.c hal_adc.c hal_i2c_master.c hal_i2c_master_internal.c hal_clock.c hal_dcxo.c hal_msdc.c hal_sd.c hal_sd_internal.c hal_sdio.c hal_sdio_internal.c hal_sdio_slave.c hal_sdio_slave_internal.c hal_eint.c hal_eint_internal.c hal_aes.c hal_des.c hal_md5.c hal_sha.c hal_spi_master.c hal_spi_master_internal.c hal_spi_slave.c hal_spi_slave_internal.c hal_rtc.c hal_wdt.c hal_wdt_internal.c hal_trng.c hal_trng_internal.c hal_pmu.c hal_pmu_wrap_interface.c hal_pwm.c hal_gpio.c hal_sys.c
  group project/mt7682_hdk/hal_examples/sleep_manager_power_mode
    ../../../../../project/mt7682_hdk/hal_examples/sleep_manager_power_mode/src/: main.c ept_gpio_var.c ept_eint_var.c system_mt7682.c
    ../../../../.././project/mt7682_hdk/hal_examples/sleep_manager_power_mode/EWARM/: startup_mt7682.s
