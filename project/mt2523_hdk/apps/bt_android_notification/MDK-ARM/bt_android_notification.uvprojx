# Keil uVision project bt_android_notification.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT2523x MediaTek
  pack: MediaTek.MTx.4.7.0
  cpu: IROM(0x08000000,0x00400000) IRAM(0x00000000,0x00400000) IRAM2(0x04008000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bt_android_notification +hex
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: MTK_DEBUG_LEVEL_INFO,MTK_DEBUG_LEVEL = info,PRODUCT_VERSION=2523,__BT_DEBUG__,MBEDTLS_CONFIG_FILE=<config-mtk-md5.h> MTK_NVDM_ENABLE
  c misc: --diag_suppress=161 --diag_suppress=1295
  c include: ..\inc;..\..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt2523\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\driver\chip\mt2523\src\common\include;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\driver\board\component\common;..\..\..\..\..\driver\board\component\lcm\ST7789H2;..\..\..\..\..\middleware\MTK\bluetooth\inc;..\..\..\..\..\prebuilt\middleware\MTK\bluetooth\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\inc;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\driver\chip\mt2523\inc;..\..\..\..\..\driver\board\mt25x3_hdk\ept\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\middleware\third_party\mbedtls\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\mt2523;..\..\..\..\..\middleware\third_party\mbedtls\configs;..\..\..\..\..\middleware\MTK\bt_notify\inc;..\..\..\..\..\middleware\MTK\bt_callback_manager\inc;..\..\..\..\..\middleware\MTK\bt_notify\inc\dogp;..\..\..\..\..\middleware\MTK\verno\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x0 size 0x400000
  memory RVCT10: RAM 0x4008000 size 0x20000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __Vectors
  group app
    ../src/: bt_init.c bt_notify_test.c ept_eint_var.c ept_gpio_var.c hci_log.c main.c regions_init.c sys_init.c ble_app_common.c gatt_service.c
  group cmsis
    ../src/: system_mt2523.c
    ./: startup_mt2523.s
  group kernel
    ../../../../../kernel/rtos/FreeRTOS/Source/: timers.c list.c queue.c tasks.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/mt2523/: port_tick.c
  group hal
    ../../../../../driver/chip/mt2523/src/: hal_accdet.c hal_accdet_internal.c hal_adc.c hal_audio.c hal_audio_enhancement.c hal_audio_internal_afe.c hal_audio_internal_pcm.c hal_audio_internal_pcm2way.c hal_audio_internal_service.c hal_audio_low_power.c hal_bsi.c hal_cache.c hal_cache_internal.c hal_charger.c hal_dac.c hal_dcm.c hal_dcxo.c hal_eint.c hal_eint_internal.c hal_emi.c hal_audio_fw_interface.c hal_audio_fw_slt.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_gdma.c hal_gdma_internal.c hal_gpio.c hal_gpt.c hal_gpt_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_i2c_pmic.c hal_i2s.c hal_i2s_internal.c hal_i2s_internal_pcm_route.c hal_isink.c hal_keypad.c hal_keypad_internal.c hal_keypad_powerkey_internal.c hal_log.c hal_mpu.c hal_mpu_internal.c hal_msdc.c hal_nvic.c hal_dwt.c hal_nvic_internal.c hal_pdma_internal.c hal_pmu.c hal_pmu_auxadc.c hal_pmu_internal.c hal_pwm.c hal_rtc.c hal_sd.c hal_sd_internal.c hal_sdio.c hal_sdio_internal.c hal_spi_master.c hal_spi_master_internal.c hal_spi_slave.c hal_spi_slave_internal.c hal_trng.c hal_trng_internal.c hal_uart.c hal_uart_internal.c hal_uart_internal_platform.c hal_usb.c hal_usb_phy.c hal_wdt.c hal_wdt_internal.c hal_wdt_retention.c hal_audio_custom.c hal_audio_internal_vm.c hal_audio_post_processing.c hal_audio_test.c hal_display_color.c hal_display_color_internal.c hal_display_dsi.c hal_display_dsi_internal.c hal_display_lcd.c hal_display_lcd_internal.c hal_display_pwm.c hal_display_pwm_internal.c hal_dvfs.c hal_misc.c hal_weak.c hal_clock_internal.c hal_dvfs_internal_vcore.c hal_dvfs_internal.c hal_pmu_wrap_interface.c hal_aes.c
    ../../../../../driver/board/mt25x3_hdk/ept/src/: bsp_gpio_ept_config.c
  group lib
    ../../../../../prebuilt/driver/chip/mt2523/lib/: libhal_core_CM4_Keil.lib libhal_protected_CM4_Keil.lib libcryptos_CM4_Keil.lib
    ../../../../../prebuilt/middleware/MTK/bluetooth/lib/: libbt_CM4_keil.lib libbtdriver_2523_CM4_keil.lib libbt_spp_CM4_keil.lib
    ../../../../../prebuilt/middleware/MTK/bt_notify/lib/: libbtnotify_Keil.lib
  group syslog
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c syslog.c toi.c os_port_callback.c
  group nvdm
    ../../../../../middleware/MTK/nvdm/src/: nvdm_port.c
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_KEIL.lib
  group bluetooth
    ../../../../../middleware/MTK/bluetooth/src/: bt_debug.c bt_hci_log.c bt_os_layer_api.c bt_task.c
    ../../../../../middleware/third_party/mbedtls/library/: md5.c aes.c
  group callback manager
    ../../../../../middleware/MTK/bt_callback_manager/src/: bt_callback_manager.c
  group bt notify service
    ../../../../../middleware/MTK/bt_notify/src/: bt_notify_conversion.c bt_notify_data_parse.c bt_notify_list.c bt_notify_task.c xml_main.c
  group dogp service
    ../../../../../middleware/MTK/bt_notify/src/dogp/: ble_dogp_adp_service.c ble_dogp_common.c ble_dogp_service.c
