# Keil uVision project CLIBaseSource.uvprojx, settings and files
target CLIBaseSource (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.6.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) IROM(0x10000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CLIBaseSource +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MTK_DEBUG_LEVEL_INFO,MTK_DEBUG_LEVEL_WARNING,MTK_DEBUG_LEVEL_ERROR,PRODUCT_VERSION=2523,MTK_NVDM_ENABLE,MTK_SYSTEM_CLOCK_104M,MTK_AT_CMD_DISABLE
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\driver\chip\mt7687\src\common\include;..\..\common\inc;..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\middleware\third_party\lwip\src\include\lwip;..\..\..\..\..\middleware\MTK\verno\inc;..\..\03_Application\Include;..\..\04_Middleware\00_FreeRTOS\Include
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\Objects\CLIBaseSource.sct
  group Application/Main
    ../../03_Application/Source/: main.c
  group Middleware/FreeRTOS
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/mt7687/: port_tick.c
  group Middleware/FreeRTOS/port
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/: tasks.c timers.c list.c queue.c
  group Driver/HAL
    ../../../../../driver/chip/mt7687/src/common/: top.c hal_gpio_7687.c dma.c pinmux.c low_hal_gpio.c nvic.c uart.c gpt.c timer.c spi_flash.c flash_sfc.c sfc.c hal_pinmux.c
    ../../../../../driver/chip/mt7687/src/: hal_gpio.c hci_log.c hal_uart.c hal_adc.c hal_gpt.c hal_nvic.c hal_nvic_internal.c hal_cache.c hal_cache_internal.c hal_log.c
  group Driver/CMSIS
    ../../01_Driver/00_CMSIS/MDK-ARM/: startup_mt7687.s system_mt7687.c
