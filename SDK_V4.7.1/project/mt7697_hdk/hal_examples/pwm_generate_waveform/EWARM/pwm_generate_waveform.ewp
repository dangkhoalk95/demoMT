# IAR project pwm_generate_waveform.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt7687\inc; ..\..\..\..\..\driver\chip\mt7687\src\common\include; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include; ..\..\..\..\..\middleware\MTK\verno\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: pwm_generate_waveform.bin
  ILINK.IlinkOutputFile: pwm_generate_waveform.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../src/: main.c
  group cmsis
    ./: startup_mt7687.s
    ../src/: system_mt7687.c
  group driver
    ../../../../../driver/chip/mt7687/src/common/: dma.c gpt.c hal_gpio_7687.c hal_pinmux.c low_hal_gpio.c low_hal_pwm.c nvic.c pinmux.c pwm.c timer.c top.c uart.c
    ../../../../../driver/chip/mt7687/src/: hal_gpio.c hal_gpt.c hal_log.c hal_nvic.c hal_nvic_internal.c hal_pwm.c hal_uart.c
