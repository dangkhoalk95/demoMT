# IAR project aws_iot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MBEDTLS_CONFIG_FILE=<config-aws-iot.h>; PCFG_OS=2; _REENT_SMALL; MTK_MINISUPP_ENABLE; MTK_BSPEXT_ENABLE; MTK_LWIP_CLI_ENABLE; MTK_HTTPCLIENT_SSL_ENABLE; PRODUCT_VERSION=7687; MTK_SMTCN_ENABLE; MTK_DEBUG_LEVEL_INFO; MTK_DEBUG_LEVEL_WARNING; MTK_DEBUG_LEVEL_ERROR; CFG_SUPPORT_SMNT_PROTO=2; MTK_WIFI_PROFILE_ENABLE; MTK_PING_OUT_ENABLE; MTK_LOAD_MAC_ADDR_FROM_EFUSE; MTK_NVDM_ENABLE; MTK_SYS_TRNG_ENABLE; SUPPORT_MBEDTLS; MTK_MINICLI_ENABLE; MTK_SINGLE_SKU_SUPPORT; MTK_LWIP_ENABLE; MTK_IPERF_ENABLE; MTK_PATCH_DL_ENABLE; MTK_FLASH_DIRECT_DL; CONFIG_REPEATER; MTK_HAL_LOWPOWER_ENABLE; __BT_DEBUG__; MTK_NVDM_ENABLE; MTK_WIFI_WPS_ENABLE
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\kernel\rtos\FreeRTOS\inc; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt7687\inc; ..\..\..\..\..\middleware\MTK\wifi_service\combo\inc; ..\..\..\..\..\middleware\MTK\dhcpd\inc; ..\..\..\..\..\middleware\MTK\minicli\inc; ..\..\..\..\..\middleware\MTK\minisupp\inc; ..\..\..\..\..\prebuilt\middleware\MTK\minisupp\inc; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt7687\src\common\include; ..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\..\..\..\middleware\third_party\lwip\src\include\lwip; ..\..\..\..\..\project\common\bsp_ex\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\third_party\ping\inc; ..\..\..\..\..\middleware\MTK\smtcn\inc; ..\..\..\..\..\middleware\MTK\smtcn\inc\internal; ..\..\..\..\..\middleware\MTK\iperf\inc; ..\..\..\..\..\driver\chip\mt7687\inc; ..\..\..\..\..\driver\board\mt76x7_hdk\util\inc; ..\..\..\..\..\middleware\MTK\wifi_service\combo\inc; ..\..\..\..\..\driver\board\mt76x7_hdk\ept\inc; ..\..\..\..\..\middleware\MTK\wifi_service\combo\inc; ..\..\..\..\..\middleware\third_party\mbedtls\include; ..\..\..\..\..\middleware\third_party\mbedtls\include\mbedtls; ..\..\..\..\..\middleware\third_party\mbedtls\configs; ..\..\..\..\..\middleware\third_party\aws_iot\samples\freertos; ..\..\..\..\..\middleware\third_party\aws_iot\tests\freertos_integration\include; ..\..\..\..\..\middleware\third_party\aws_iot\include; ..\..\..\..\..\middleware\third_party\aws_iot\platform\freertos; ..\..\..\..\..\middleware\third_party\aws_iot\external_libs\jsmn; ..\..\..\..\..\middleware\MTK\connsys\inc; ..\..\..\..\..\middleware\MTK\verno\inc; ..\..\..\..\..\driver\board\mt76x7_hdk\external_flash\inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\project\common\certs\aws; ..\customer
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: aws_iot.bin
  ILINK.IlinkOutputFile: aws_iot.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect calloc=pvPortCalloc; --redirect realloc=pvPortRealloc; --redirect free=vPortFree
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group apps
    ../src/: aws_iot_test.c ept_eint_var.c ept_gpio_var.c main.c regions_init.c sys_init.c wifi_lwip_helper.c wifi_nvdm_config.c
  group aws_iot
    ../../../../../middleware/third_party/aws_iot/src/: aws_iot_json_utils.c aws_iot_mqtt_client.c aws_iot_mqtt_client_common_internal.c aws_iot_mqtt_client_connect.c aws_iot_mqtt_client_publish.c aws_iot_mqtt_client_subscribe.c aws_iot_mqtt_client_unsubscribe.c aws_iot_mqtt_client_yield.c aws_iot_shadow.c aws_iot_shadow_actions.c aws_iot_shadow_json.c aws_iot_shadow_records.c
    ../../../../../middleware/third_party/aws_iot/platform/freertos/: aws_iot_timer.c network_mbedtls_wrapper.c threads_mutex_wrapper.c
    ../../../../../middleware/third_party/aws_iot/external_libs/jsmn/: jsmn.c
  group aws_iot_test
    ../../../../../middleware/third_party/aws_iot/tests/freertos_integration/src/: aws_iot_test_auto_reconnect.c aws_iot_test_basic_connectivity.c aws_iot_test_multiple_clients.c
    ../../../../../middleware/third_party/aws_iot/tests/freertos_integration/multithreadingTest/: aws_iot_test_multithreading_validation.c
    ../../../../../middleware/third_party/aws_iot/samples/freertos/shadow_sample_console_echo/: shadow_console_echo.c
    ../../../../../middleware/third_party/aws_iot/samples/freertos/shadow_sample/: shadow_sample.c
    ../../../../../middleware/third_party/aws_iot/samples/freertos/subscribe_publish_library_sample/: subscribe_publish_library_sample.c
    ../../../../../middleware/third_party/aws_iot/samples/freertos/subscribe_publish_sample/: subscribe_publish_sample.c
  group bsp
    ../../../../../driver/board/mt76x7_hdk/util/src/: board_cli.c gpio_cli.c io_def.c
    ../../../../../driver/board/mt76x7_hdk/external_flash/src/: bsp_flash_config.c
    ../../../../../driver/board/mt76x7_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../middleware/MTK/wifi_service/combo/src/: get_profile_string.c inband_queue_option.c misc.c wifi_cli.c wifi_cm4_scan.c wifi_inband_cli.c wifi_os_api.c wifi_profile.c wifi_repeater.c wifi_wps.c
    ../../../../../prebuilt/middleware/MTK/wifi_service/combo/lib/wifi_supp/: libwifi_CM4_IAR.a
    ../../../../../middleware/MTK/wifi_service/combo/src/wifi_os_ext/: os_util.c os_utils.c
    ../../../../../middleware/MTK/wifi_service/combo/src/init/: wifi_default_config.c wifi_init.c
  group bspex
    ../../../../common/bsp_ex/src/: lp_ex_sleep.c
  group cmsis
    ./: startup_mt7687.s
    ../src/: system_mt7687.c
  group dhcpd
    ../../../../../middleware/MTK/dhcpd/src/: dhcpd.c
  group driver
    ../../../../../middleware/MTK/connsys/src/: connsys_bus.c connsys_driver.c connsys_util.c
    ../../../../../driver/chip/mt7687/src/common/: cos_api.c dma.c flash_sfc.c gpt.c hal_gpc.c hal_gpio_7687.c hal_I2C.c hal_i2s_internal.c hal_irrx.c hal_lp.c hal_pcnt.c hal_pinmux.c hal_spim.c hal_sys.c hal_trng.c hal_uid.c i2c.c ir_tx.c low_hal_gpio.c low_hal_irrx.c low_hal_irtx.c low_hal_pwm.c low_hal_rtc.c low_hal_wdt.c nvic.c pinmux.c pwm.c sfc.c spi_flash.c spim.c timer.c top.c uart.c
    ../../../../../driver/chip/mt7687/src/: hal_adc.c hal_aes.c hal_cache.c hal_cache_internal.c hal_des.c hal_dwt.c hal_eint.c hal_flash.c hal_gdma.c hal_gpio.c hal_gpt.c hal_i2c_master.c hal_i2s.c hal_irtx.c hal_log.c hal_md5.c hal_nvic.c hal_nvic_internal.c hal_pwm.c hal_rtc.c hal_sha.c hal_spi_master.c hal_uart.c hal_wdt.c
    ../../../../../prebuilt/driver/chip/mt7687/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
  group kernel
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/mt7687/: port_tick.c
  group kservice
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c os_cli.c os_port_callback.c syslog.c syslog_cli.c toi.c
  group lwip
    ../../../../../middleware/third_party/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../middleware/third_party/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
    ../../../../../middleware/third_party/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c upap.c utils.c vj.c
    ../../../../../middleware/third_party/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c ip4.c ip4_addr.c ip_frag.c
    ../../../../../middleware/third_party/lwip/src/core/: def.c dhcp.c dns.c inet_chksum.c init.c lwip_timers.c mem.c memp.c netif.c raw.c stats.c sys.c tcp.c tcp_in.c udp.c
    ../../../../../middleware/third_party/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../middleware/third_party/lwip/src/netif/: etharp.c slipif.c
    ../../../../../middleware/third_party/lwip/ports/: ethernetif.c lwip_cli.c lwip_log.c pbuf.c sys_arch.c tcp_out.c
  group mbedtls
    ../../../../../middleware/third_party/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../../../../middleware/third_party/mbedtls/configs/: config-aws-iot.h
  group minicli
    ../../../../../prebuilt/middleware/MTK/minicli/lib/: libminicli_CM4_IAR.a
    ../../../../../middleware/MTK/minicli/src/: minicli_api.c
  group minisupp
    ../../../../../prebuilt/middleware/MTK/minisupp/lib/: libminisupp_wps_CM4_IAR.a
  group nvdm
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_IAR.a
    ../../../../../middleware/MTK/nvdm/src/: nvdm_cli.c nvdm_port.c
  group smtcn
    ../../../../../middleware/MTK/smtcn/src/: bsmtcn_ops.c elian.c ops_config.c smt_api.c smt_conn.c
    ../../../../../prebuilt/middleware/MTK/smtcn/lib/: libbcsmtcn_CM4_IAR.a libmcsmtcn_CM4_IAR.a
