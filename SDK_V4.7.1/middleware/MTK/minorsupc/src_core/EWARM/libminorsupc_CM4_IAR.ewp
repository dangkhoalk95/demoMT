# IAR project libminorsupc_CM4_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MTK_DEBUG_LEVEL_INFO; PRODUCT_VERSION=2523; MTK_NVDM_ENABLE; MTK_WIFI_ENABLE; MTK_WIFI_CHIP_USE=MT5931; MTK_FOTA_ENABLE; MTK_WIFI_CHIP_USE_MT5931; MT5931; __WIFI_SUPPORT__; WCN_MAUI; __MTK_TARGET__; CONFIG_DRIVER_MTK=1
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023,Pe186,Pe021,Pe177,Pe301
  ICCARM.CCIncludePath2: ..\..\..\..\..\driver\board\mt25x3_hdk\wifi\mt5931\inc; ..\..\..\..\..\driver\chip\mt2523\inc; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\inc; ..\..\inc\aes; ..\..\inc\dhm; ..\..\..\..\..\project\mt2523_hdk\apps\modem_wifi5931_ref_design\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libhal_protected_CM4_IAR.out
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: inc; ..\..\..\inc; ..\..\..\..\inc; ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\CMSIS\Device\MTK\mt2523\Include; ..\..\..\..\..\..\kernel\service\inc
  ICCARM.CCOptLevel: 3
  group src
    ../aes/: aes_engine.c aes_wrap.c
    ../dhm/: bignum.c dhm.c
    ../: che_api.c common.c crypto.c driver_mtk.c drivers.c l2_packet.c md4.c md5.c ms_funcs.c rc4.c sha1.c sha256.c supc_adpt_functions.c supc_create.c supc_init.c supc_main.c supc_wpa_common.c supc_wpa_functions.c wpa.c wpa_supplicant.c wpabuf.c
    ../eap/: milenage_dummy.c
