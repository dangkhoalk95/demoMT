# IAR project libwndrv_CM4_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MTK_DEBUG_LEVEL_INFO; PRODUCT_VERSION=2523; MTK_NVDM_ENABLE; MTK_WIFI_ENABLE; MTK_WIFI_CHIP_USE=MT5931; MTK_FOTA_ENABLE; MTK_WIFI_CHIP_USE_MT5931; MT5931; __WIFI_HIF_SDIO__=1; __WIFI_SUPPORT__; WCN_MAUI; __MTK_TARGET__
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023,Pe186,Pe021,Pe177,Pe301
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include; ..\..\..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\..\..\driver\chip\mt2523\inc; ..\..\..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\..\driver\board\mt25x3_hdk\ept\inc; ..\..\..\..\..\..\..\driver\board\mt25x3_hdk\keypad\inc; ..\..\..\..\..\..\..\project\mt2523_hdk\apps\modem_wifi5931_ref_design\inc; ..\..\inc\mgmt; ..\..\inc\nic; ..\..\inc\os; ..\..\inc\release_mt5931; ..\..\inc; ..\..\..\..\..\mt25x3_hdk\wifi\mt5931\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libhal_protected_CM4_IAR.out
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: inc; ..\..\..\inc; ..\..\..\..\inc; ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\CMSIS\Device\MTK\mt2523\Include; ..\..\..\..\..\..\kernel\service\inc
  ICCARM.CCOptLevel: 3
  group src
    ../mgmt/: aaa_fsm.c ais_fsm.c assoc.c auth.c bss.c cnm.c cnm_mem.c cnm_timer.c hem_mbox.c mib.c privacy.c rate.c rlm.c rlm_domain.c rlm_obss.c roaming_fsm.c rsn.c saa_fsm.c scan.c scan_fsm.c sec_fsm.c sms4.c swcr.c wapi.c
    ../nic/: cmd_buf.c nic.c nic_cmd_event.c nic_pwr_mgt.c nic_rx.c nic_tx.c que_mgt.c
    ../os/: gl_hpi.c gl_kal.c gl_rftest.c loopback.c mt5931_firmware.c wlan_kal.c wlan_wt.c wndrv_create.c wndrv_hostap_func.c wndrv_inject_msg.c wndrv_main.c wndrv_misc.c wndrv_rftest_func.c wndrv_supc_func.c
    ../common/: smart_conn_decoder.c wlan_bow.c wlan_lib.c wlan_oid.c wndrv_crypt_aes.c
    ../release_mt5931/: wndrv_api.c wndrv_kal.c
