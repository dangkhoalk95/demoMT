# IAR project libwifibsp_CM4_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MTK_DEBUG_LEVEL_INFO; PRODUCT_VERSION=2523; MTK_NVDM_ENABLE; MTK_WIFI_ENABLE; MTK_WIFI_CHIP_USE=MT5931; MTK_FOTA_ENABLE; MTK_WIFI_CHIP_USE_MT5931; MT5931; __WIFI_HIF_SDIO__=1; __WIFI_SUPPORT__; WCN_MAUI; __MTK_TARGET__
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023,Pe186,Pe021,Pe177,Pe301
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Device\MTK\mt2523\Include; ..\..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\chip\mt2523\inc; ..\..\..\..\..\..\chip\inc; ..\..\..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\..\..\middleware\MTK\atci\inc; ..\..\..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\..\..\middleware\third_party\lwip\src\include\lwip; ..\..\..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\inc; ..\..\..\..\..\component\wifi\mt5931\inc; ..\..\..\..\..\..\..\project\mt2523_hdk\apps\modem_wifi5931_ref_design\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libhal_protected_CM4_IAR.out
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: inc; ..\..\..\inc; ..\..\..\..\inc; ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\CMSIS\Device\MTK\mt2523\Include; ..\..\..\..\..\..\kernel\service\inc
  ICCARM.CCOptLevel: 3
  group src
    ../: kal_public_api.c mtk_hw_adapter.c mtk_wifi_adapter.c stack_ltlcom.c wifi_api.c wifi_atci.c wifi_common_config.c wndrv_configure.c
