# Keil uVision project freertos.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.6.2
  cpu: IROM(0x10000000,0x00400000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: MTK_HAL_NO_LOG_ENABLE
  c include: .\inc;..\..\..\..\driver\chip\mt7687\inc
  memory RVCT4: ROM 0x10000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __isr_vector
  group App
    ./: main.c
    ./src/: startup_mt7687.s system_mt7687.c
software components: CMSIS:CORE 4.1.0, Device:HAL:ADC 4.6.0, Device:HAL:CACHE 4.6.0, Device:HAL:COMMON 4.6.0, Device:HAL:Crypto 4.6.0, Device:HAL:EINT 4.6.0, Device:HAL:FLASH 4.6.0, Device:HAL:GDMA 4.6.0, Device:HAL:GPC 4.6.0, Device:HAL:GPIO 4.6.0, Device:HAL:GPT 4.6.0, Device:HAL:I2C MASTER 4.6.0, Device:HAL:I2S 4.6.0, Device:HAL:IRDA 4.6.0, Device:HAL:PWM 4.6.0, Device:HAL:RTC 4.6.0, Device:HAL:SPI MASTER 4.6.0, Device:HAL:TRNG 4.6.0, Device:HAL:UART 4.6.0, Device:HAL:WDT 4.6.0, Device:RTOS:Free RTOS 4.6.0
