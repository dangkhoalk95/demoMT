# Keil uVision project libminorsupc_CM4_KEIL.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT2523x MediaTek
  pack: MediaTek.MTx.4.2.0
  cpu: IROM(0x08000000,0x00400000) IRAM(0x00000000,0x00400000) IRAM2(0x04008000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: libminorsupc_CM4_KEIL (library)
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: MTK_DEBUG_LEVEL_INFO PRODUCT_VERSION=2523 MTK_NVDM_ENABLE MTK_WIFI_ENABLE MTK_WIFI_CHIP_USE=MT5931 MTK_FOTA_ENABLE MTK_WIFI_CHIP_USE_MT5931 MT5931 __WIFI_SUPPORT__ WCN_MAUI __MTK_TARGET__ CONFIG_DRIVER_MTK=1
  c misc: --C99 --diag_suppress=1295
  c include: ..\..\..\..\..\driver\board\mt25x3_hdk\wifi\mt5931\inc;..\..\..\..\..\driver\chip\mt2523\inc;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\driver\CMSIS\Device\MTK\mt2523\Include;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\inc;..\..\inc\aes;..\..\inc\dhm;..\..\..\..\..\project\mt2523_hdk\apps\modem_wifi5931_ref_design\inc
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x0 size 0x400000
  memory RVCT10: RAM 0x4008000 size 0x20000
  group src
    ../aes/: aes_engine.c aes_wrap.c
    ../dhm/: bignum.c dhm.c
    ../: che_api.c common.c crypto.c driver_mtk.c drivers.c l2_packet.c md4.c md5.c ms_funcs.c rc4.c sha1.c sha256.c supc_adpt_functions.c supc_create.c supc_init.c supc_main.c supc_wpa_common.c supc_wpa_functions.c wpa.c wpa_supplicant.c wpabuf.c
    ../eap/: milenage_dummy.c
